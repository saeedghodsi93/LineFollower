# Keil uVision project USBHostLite.uvproj, settings and files
target LPC17xx_IRAM (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USBHostLite +hex
  c flags: Optim=1
  c define: __IRAM
  c include: .\UsbHost\Include;.;..\common\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Common
    ./: core_cm3.c LPC17xx.h startup_LPC17xx.s system_LPC17xx.h system_LPC17xx.c SYS.H
  group Touch
    ./: i2c.c i2c.h Touch.C Touch.h Touch_DEF.H
  group USB
    ./: USB.c USB.h usbhost_err.h usbhost_fat.c usbhost_fat.h usbhost_inc.h usbhost_ms.h usbhost_ms.c usbhost_lpc17xx.h usbhost_lpc17xx.c usbhost_uart.h usbhost_uart.c lpc_types.h lpc17xx_clkpwr.c lpc17xx_clkpwr.h lpc17xx_dac.c lpc17xx_dac.h lpc17xx_gpio.c lpc17xx_gpio.h lpc17xx_libcfg.h lpc17xx_libcfg_default.c lpc17xx_libcfg_default.h lpc17xx_pinsel.c lpc17xx_pinsel.h lpc17xx_timer.c lpc17xx_timer.h
  group Images
    ./: ARM_Ani_16bpp.c ARM_Ani_16bpp_fh_fv.c Bg_16bpp_b.c Bg_16bpp_b_fh_fv.c Bg_16bpp_l.c Bg_16bpp_t.c Bg_16bpp_r_fh_fv.c Bg_16bpp_r.c Bg_16bpp_l_fh_fv.c Bg_16bpp_t_fh_fv.c
  group GLCD
    ./: GLCD.c GLCD.h GLCD_DEF.H
  group Uart
    ./: uart.c uart.h
  group Main
    ./: Main.c
target LPC17xx_IFLASH (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: USBHostLite +hex
  c flags: Optim=1
  c include: .\UsbHost\Include;.\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
